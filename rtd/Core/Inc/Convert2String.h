#ifndef CONVERT2STRING_H_
#define CONVERT2STRING_H_

// Быстрое преобразование беззнакового 32-битного целого числа в десятичную строку с контролем границ буфера
static inline size_t uint32_to_str(uint32_t value, char *buf, size_t buf_size)
{
    if (!buf || buf_size == 0) return 0; // Если указатель на буфер пуст или его размер равен нулю, сразу возвращаем 0 записанных символов
    char tmp[11]; // Временный стек-буфер для цифр в обратном порядке (максимум 10 цифр для 4294967295 плюс '\0')
    size_t len = 0; // Счётчик извлечённых десятичных разрядов

    if (value == 0) { // Отдельная обработка частного случая, когда входное число равно нулю
        if (buf_size > 1) { // Проверяем, что в выходном буфере есть место под символ '0' и завершающий нуль-терминатор
            buf[0] = '0'; // Записываем символ нуля
            buf[1] = '\0'; // Завершаем Си-строку нулевым байтом
        }
        return 1; // Возвращаем длину строки (1 символ)
    }

    while (value > 0 && len < sizeof(tmp) - 1) { // Пока от числа остаются ненулевые разряды и не достигнут предел временного буфера
        tmp[len++] = (char)('0' + (value % 10)); // Выделяем младшую десятичную цифру остатком от деления на 10 и переводим в ASCII-код
        value /= 10; // Отбрасываем обработанный младший разряд целочисленным делением на 10
    }
    tmp[len] = '\0'; // Терминируем временный массив

    size_t i = 0; // Индекс записи символов в целевой выходной буфер buf
    while (len > 0 && i < buf_size - 1) { // Разворачиваем строку: копируем цифры из конца tmp в начало buf, оставляя 1 байт под '\0'
        buf[i++] = tmp[--len]; // Переносим старшие разряды первыми
    }
    buf[i] = '\0'; // Записываем завершающий нуль-терминатор в конец выходной строки
    return i; // Возвращаем фактическое количество записанных символов (без учёта '\0')
}

// Форматирование числа с плавающей точкой в строку с фиксированными 2 знаками после точки (формат "[-]X.XX")
static inline size_t float_to_str_2dec(float val, char *buf, size_t buf_size)
{
    if (!buf || buf_size < 6) return 0; // Проверяем буфер: минимальная строка с минусом "-0.00\0" требует не менее 6 байт
    int is_negative = (val < 0.0f); // Запоминаем знак исходного числа (1 — отрицательное, 0 — неотрицательное)
    if (is_negative) val = -val; // Переводим число в абсолютное положительное значение для удобства целочисленного округления

    uint32_t total = (uint32_t)(val * 100.0f + 0.5f); // Переводим число в сотые доли с математическим округлением (+0.5f перед усечением дробной части)
    uint32_t int_part = total / 100; // Выделяем целую часть числа делением на 100
    uint32_t frac_part = total % 100; // Выделяем дробную часть (сотые доли в диапазоне 0..99) остатком от деления на 100

    size_t pos = 0; // Текущая позиция записи в выходном буфере
    if (is_negative && total > 0 && pos + 1 < buf_size) { // Выводим знак '-', только если число было отрицательным и после округления не превратилось в чистый 0.00
        buf[pos++] = '-'; // Записываем символ минуса в начало буфера
    }

    pos += uint32_to_str(int_part, buf + pos, buf_size - pos); // Конвертируем целую часть в строку и сдвигаем индекс pos на длину целой части
    if (pos + 3 < buf_size) { // Проверяем, осталось ли в буфере минимум 4 байта под точку, два дробных знака и терминатор '\0'
        buf[pos++] = '.'; // Записываем разделительную десятичную точку
        buf[pos++] = (char)('0' + (frac_part / 10)); // Вычисляем и записываем цифру десятых долей (первый знак после точки)
        buf[pos++] = (char)('0' + (frac_part % 10)); // Вычисляем и записываем цифру сотых долей (второй знак после точки)
        buf[pos] = '\0'; // Завершаем строку нуль-терминатором
    } else { // Если размер буфера оказался недостаточным для дробной части
        buf[0] = '\0'; // Делаем выходную строку пустой во избежание выдачи обрезанного числа
        return 0; // Возвращаем признак ошибки нехватки места (0)
    }
    return pos; // Возвращаем итоговую длину сформированной строки в байтах
}

// Форматирование числа с плавающей точкой в строку с фиксированными 3 знаками после точки (формат "[-]X.XXX")
static inline size_t float_to_str_3dec(float val, char *buf, size_t buf_size)
{
    if (!buf || buf_size < 7) return 0; // Минимальная строка с минусом "-0.000\0" требует не менее 7 байт
    int is_negative = (val < 0.0f); // Фиксируем наличие отрицательного знака
    if (is_negative) val = -val; // Берём модуль числа

    uint32_t total = (uint32_t)(val * 1000.0f + 0.5f); // Масштабируем число в тысячные доли и округляем до ближайшего целого (+0.5f)
    uint32_t int_part = total / 1000; // Находим целую часть делением на 1000
    uint32_t frac_part = total % 1000; // Находим дробную часть из трёх цифр (0..999) остатком от деления на 1000

    size_t pos = 0; // Смещение текущей позиции записи в буфере
    if (is_negative && pos + 1 < buf_size) { // Если число отрицательное и буфер позволяет
        buf[pos++] = '-'; // Записываем символ знака минус
    }

    pos += uint32_to_str(int_part, buf + pos, buf_size - pos); // Дописываем строковое представление целой части числа

    if (pos + 4 < buf_size) { // Убеждаемся, что в буфере хватает места под точку, 3 цифры дробной части и '\0'
        buf[pos++] = '.'; // Ставим десятичную точку
        buf[pos++] = (char)('0' + (frac_part / 100)); // Записываем разряд десятых долей (сотни от числа 0..999)
        buf[pos++] = (char)('0' + ((frac_part / 10) % 10)); // Записываем разряд сотых долей (десятки от числа 0..999)
        buf[pos++] = (char)('0' + (frac_part % 10)); // Записываем разряд тысячных долей (единицы от числа 0..999)
    }
    buf[pos] = '\0'; // Ставим завершающий нулевой символ конца строки
    return pos; // Возвращаем количество записанных печатных символов
}

// Вычисление среднего арифметического четырёх 16-битных отсчётов с математическим округлением
static uint16_t Average4_Array(const uint16_t *data)
{
    uint32_t sum = (uint32_t)data[0] + data[1] + data[2] + data[3]; // Складываем 4 элемента в 32-битный аккумулятор, исключая переполнение 16-битной сетки
    return (uint16_t)((sum + 2) >> 2); // Прибавляем половину делителя (+2) для округления к ближайшему целому и делим на 4 быстрым сдвигом вправо на 2 бита
}

#endif //
