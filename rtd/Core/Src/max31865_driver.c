#include "max31865_driver.h"
#include <string.h>

// Внутренняя обёртка для вызова аппаратного callback-метода передачи по SPI с проверкой указателей
static max31865_result_t exchange(max31865_t *d, const uint8_t *tx, uint8_t *rx, size_t n)
{
    // Если указатель на драйвер или функцию SPI-обмена равен NULL, возвращаем ошибку аргумента
    if (!d || !d->transfer) return MAX31865_BAD_ARGUMENT;
    // Вызываем платформенный SPI-обмен; преобразуем код возврата 0 в MAX31865_OK, а ошибку — в
    // MAX31865_IO_ERROR
    return d->transfer(d->context, tx, rx, n) ? MAX31865_IO_ERROR : MAX31865_OK;
}

// Запись байта конфигурации в регистр 0x80 микросхемы MAX31865 с обязательной проверкой обратным
// чтением (Readback)
static max31865_result_t configure(max31865_t *d, uint8_t config)
{
    // Формируем 2-байтовый пакет записи: байт 0 — адрес записи конфигурации (0x80), байт 1 — новое
    // значение регистра
    uint8_t tx[2] = {MAX31865_CONFIG_WRITE, config};
    uint8_t rx[2] = {0}; // Приёмный буфер для полнодуплексной SPI-транзакции
    max31865_result_t result = exchange(d, tx, rx, 2); // Отправляем команду записи конфигурации в чип
    // Если сама SPI-транзакция завершилась ошибкой или таймаутом, сразу выходим
    if (result != MAX31865_OK) return result;

    // Готовим вторую транзакцию: байт 0 — адрес чтения регистра конфигурации (0x00)
    tx[0] = MAX31865_CONFIG_READ;
    // Второй передаваемый байт холостой (0x00), во время него микросхема выставит на линию MISO
    // содержимое регистра
    tx[1] = 0;
    result = exchange(d, tx, rx, 2); // Выполняем чтение регистра конфигурации по SPI
    if (result != MAX31865_OK) return result; // При аппаратном сбое шины выходим с кодом ошибки ввода-вывода
    // Если прочитанный байт не совпал с записанным (например, обрыв MISO/MOSI или не сработал CS),
    // возвращаем ошибку верификации
    if (rx[1] != config) return MAX31865_CONFIG_ERROR;
    d->config = config; // Сохраняем подтверждённый байт конфигурации в структуре состояния драйвера
    return MAX31865_OK; // Запись и верификация прошли успешно
}

// Первичная инициализация экземпляра драйвера MAX31865 (выбор схемы подключения 2/3/4 провода и
// режекторного фильтра 50/60 Гц)
max31865_result_t max31865_init(max31865_t *d, void *context, max31865_transfer_fn transfer, unsigned wires, unsigned filter_hz)
{
    if (!d || !transfer || (wires != 2 && wires != 3 && wires != 4) ||
        // Проверяем валидность указателей, допустимое число проводов (2, 3, 4) и частоту фильтра
        // (50 или 60 Гц)
        (filter_hz != 50 && filter_hz != 60)) return MAX31865_BAD_ARGUMENT;
    // Сохраняем указатель на аппаратный контекст канала (структуру с пинами CS/DRDY и дескриптором
    // SPI)
    d->context = context;
    d->transfer = transfer; // Сохраняем указатель на функцию обмена по SPI
    d->config = 0; // Обнуляем сохранённую теневую конфигурацию до успешной записи в чип
    return configure(d, (uint8_t)(
        // Устанавливаем бит D4 (3-Wire = 1) для 3-проводной схемы, либо 0 для 2- и 4-проводной схем
        (wires == 3 ? MAX31865_THREE_WIRE : 0) |
        // Устанавливаем бит D0 (50Hz = 1) для подавления сетевых помех 50 Гц, либо 0 для 60 Гц
        // (Vbias и Auto пока выключены)
        (filter_hz == 50 ? MAX31865_FILTER_50HZ : 0)));
}

// Перевод датчика в режим непрерывных автоматических преобразований (включение битов Vbias и
// Conversion Mode = Auto)
max31865_result_t max31865_start(max31865_t *d)
{
    // Проверка корректности инициализации структуры драйвера
    if (!d || !d->transfer) return MAX31865_BAD_ARGUMENT;
    // Дополняем текущую конфигурацию битами D7 (Vbias = 1) и D6 (Conversion Mode Auto = 1) и
    // записываем с проверкой
    return configure(d, (uint8_t)(d->config | MAX31865_AUTO | MAX31865_BIAS));
}

// Предварительное включение только источника опорного напряжения Vbias без запуска преобразований
// АЦП
max31865_result_t max31865_bias(max31865_t *d)
{
    // Проверяем, что контекст драйвера и callback SPI заданы
    if (!d || !d->transfer) return MAX31865_BAD_ARGUMENT;
    // Оставляем только пассивные настройки (число проводов и фильтр), принудительно сбрасываем AUTO
    // и включаем бит D7 (Vbias)
    return configure(d, (uint8_t)((d->config & MAX31865_PASSIVE_MASK) | MAX31865_BIAS));
}

// Полное отключение тока смещения Vbias и непрерывного режима AUTO (перевод в энергосберегающий
// режим без самонагрева датчика)
max31865_result_t max31865_stop(max31865_t *d)
{
    if (!d || !d->transfer) return MAX31865_BAD_ARGUMENT; // Проверка валидности структуры драйвера
    // Сбрасываем биты Vbias и AUTO в теневом регистре конфигурации, сохраняя только настройки
    // проводов и фильтра 50/60 Гц
    d->config &= MAX31865_PASSIVE_MASK;
    // Записываем пассивную конфигурацию в микросхему и проверяем по Readback, что чип действительно
    // отключил ток
    return configure(d, d->config);
}

// Пакетное (Burst) чтение кода АЦП и регистра статуса аппаратных ошибок за одну SPI-транзакцию
max31865_result_t max31865_read(max31865_t *d, max31865_sample_t *sample)
{
    // Байт 0 — стартовый адрес чтения 0x01 (RTD MSB), далее 7 нулевых байтов для вычитывания
    // регистров 0x01..0x07 подряд
    uint8_t tx[8] = {MAX31865_SAMPLE_READ, 0, 0, 0, 0, 0, 0, 0};
    // Буфер для приёма ответа (rx[1..2] — код RTD, rx[3..6] — пороги High/Low Fault, rx[7] —
    // регистр Fault Status 0x07)
    uint8_t rx[8] = {0};
    max31865_result_t result; // Код результата SPI-транзакции
    uint16_t word; // 16-битное слово, собранное из двух регистров RTD (0x01 и 0x02)

    // Защита от передачи нулевого указателя на структуру результата
    if (!sample) return MAX31865_BAD_ARGUMENT;
    memset(sample, 0, sizeof(*sample)); // Очищаем выходную структуру перед чтением
    // Выполняем 8-байтовый пакетный обмен по SPI при удерживаемом низком уровне CS
    result = exchange(d, tx, rx, sizeof(tx));
    if (result != MAX31865_OK) return result; // При ошибке SPI выходим, оставляя поля sample обнулёнными

    // Склеиваем старший байт RTD MSB (rx[1]) и младший байт RTD LSB (rx[2]) в единое 16-битное
    // слово
    word = (uint16_t)(((uint16_t)rx[1] << 8) | rx[2]);
    // Сдвигаем слово на 1 бит вправо, выделяя чистый 15-битный беззнаковый код отношения
    // сопротивлений (0..32767)
    sample->raw = word >> 1;
    // Извлекаем младший бит D0 регистра RTD LSB — общий аппаратный флаг обнаружения неисправности
    // (Fault bit)
    sample->sensor_fault = (uint8_t)(word & 1u);
    // Из байта регистра 0x07 (Fault Status) выделяем 6 старших диагностических битов (обрыв/КЗ
    // линий RTD и Vref), отбрасывая 2 младших резервных бита
    sample->faults = rx[7] & MAX31865_FAULT_MASK;
    return MAX31865_OK; // Чтение регистров успешно выполнено
}

// Сброс защёлкнутых флагов аппаратных ошибок в регистре Fault Status микросхемы MAX31865
max31865_result_t max31865_clear_faults(max31865_t *d)
{
    uint8_t tx[2]; // Буфер из 2 байтов для отправки команды записи в конфигурационный регистр
    uint8_t rx[2] = {0}; // Приёмный буфер SPI
    if (!d || !d->transfer) return MAX31865_BAD_ARGUMENT; // Проверка указателей контекста и функции передачи
    tx[0] = MAX31865_CONFIG_WRITE; // Адрес записи регистра конфигурации (0x80)
    // Добавляем к текущей конфигурации самосбрасывающийся бит D1 (Fault Status Clear = 1)
    tx[1] = (uint8_t)(d->config | MAX31865_CLEAR_FAULT);
    // Отправляем команду по SPI (readback здесь не делается, так как бит D1 автоматически
    // сбрасывается самой микросхемой в 0 сразу после очистки ошибок)
    return exchange(d, tx, rx, 2);
}
