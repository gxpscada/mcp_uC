#include "device_stream.h"

// Форматирование кадра измерений в текстовую строку и постановка её в конец очереди отправки
void device_stream_push(device_stream_t *s, const device_frame_t *f)
{
    unsigned index; // Индекс слота в кольцевом буфере строк, куда будет записана новая строка
    size_t n; // Длина сформированной строки в байтах

    if (s->count == DEVICE_STREAM_DEPTH) { // Если очередь уже полностью заполнена неотправленными строками
        ++s->dropped; // Увеличиваем диагностический счётчик потерянных (отброшенных) кадров
        return; // Выходим, сохраняя целостность уже стоящих в очереди старых строк
    }
    // Вычисляем индекс первого свободного слота за хвостом очереди
    index = (s->head + s->count) % DEVICE_STREAM_DEPTH;
    // Форматируем 4 канала кадра в текстовый буфер выбранного слота
    n = device_ascii_format(f, s->lines[index], DEVICE_LINE_SIZE);
    if (!n) { // Если функция форматирования вернула 0 (ошибка буфера или аргументов)
        ++s->dropped; // Учитываем кадр как отброшенный
        return; // Выходим без увеличения счётчика элементов очереди
    }
    s->lengths[index] = (uint16_t)n; // Сохраняем фактическую длину полученной строки для последующей передачи
    ++s->count; // Увеличиваем количество готовых к отправке строк в очереди
}

// Попытка неблокирующей отправки самой старой строки из головы очереди через интерфейс передачи
void device_stream_poll(device_stream_t *s, void *ctx, int (*send)(void *, const uint8_t *, size_t))
{
    // Если в очереди есть строки и передатчик (например, USB CDC) принял головную строку (вернул 0)
    if (s->count && send(ctx, (const uint8_t *)s->lines[s->head], s->lengths[s->head]) == 0) {
        // Сдвигаем указатель головы очереди к следующей строке по кольцу
        s->head = (s->head + 1u) % DEVICE_STREAM_DEPTH;
        --s->count; // Уменьшаем число ожидающих строк в очереди на единицу
        ++s->accepted; // Инкрементируем счётчик успешно отправленных строк
    }
}
