#include "device_store.h"
#include "device_control.h"
#include <string.h>

#define STORE_MAGIC 0x50544332u // Заголовочная сигнатура записи конфигурации ('PTC2' в ASCII)
#define STORE_COMMIT 0x43464732u // Финальный маркер успешного завершения записи слота ('CFG2' в ASCII)

// Расчёт 32-битного проверочного слова (CRC-16 и её побитовая инверсия) для первых 17 слов записи
// (68 байт)
static uint32_t checksum(const uint32_t *r)
{
    // Байтовый буфер для сериализации 17 слов записи в независимый от архитектуры порядок
    // Little-Endian
    uint8_t bytes[68];
    unsigned i; // Счётчик байтов (от 0 до 67)
    uint32_t crc; // Переменная для 16-битной контрольной суммы

    // Раскладываем каждое из 17 слов (r[0]..r[16]) на 4 отдельных байта от младшего к старшему
    for (i = 0; i < 68; ++i)
        // Извлекаем соответствующий байт слова сдвигом на 0, 8, 16 или 24 бита
        bytes[i] = (uint8_t)(r[i / 4] >> (8u * (i % 4)));
    // Вычисляем стандартную CRC-16 по полученным 68 байтам заголовка и данных
    crc = modbus_crc16(bytes, sizeof(bytes));
    // В младшие 16 бит кладём саму CRC, а в старшие 16 бит — её побитовую инверсию (защита от
    // обнуления/залипания слова во Flash)
    return crc | ((crc ^ 0xffffu) << 16);
}

// Сканирование сектора Flash и загрузка самой свежей валидной записи конфигурации
int device_store_load(device_store_t *s, device_config_t *out)
{
    size_t slot; // Смещение начала текущей проверяемой записи (в 32-битных словах от начала сектора)
    int found = 0; // Флаг: 1 — найдена и загружена хотя бы одна целая запись, 0 — валидных записей нет

    s->next_slot = 0; // По умолчанию первая запись будет производиться в самое начало сектора (слот 0)
    s->state = 0; // Сбрасываем состояние автомата пословной записи в покой (0)
    s->error = 0; // Сбрасываем флаг ошибки записи

    // Шагаем по сектору Flash блоками по 20 слов (DEVICE_STORE_WORDS)
    for (slot = 0; slot + DEVICE_STORE_WORDS <= s->word_count; slot += DEVICE_STORE_WORDS) {
        // Локальный буфер в ОЗУ для вычитывания одного слота (20 слов = 80 байт)
        uint32_t r[DEVICE_STORE_WORDS];
        unsigned i; // Индекс внутри слота
        // Признак того, что слот не является полностью чистым (хотя бы один бит сброшен из 1 в 0)
        unsigned used = 0;
        device_config_t c; // Временная структура конфигурации для проверки прочитанной записи
        uint16_t map[DEVICE_HOLDING_COUNT]; // Временный массив распакованных 16-битных регистров
        uint16_t flags; // Поле упакованных битовых флагов фильтрации и калибровки

        for (i = 0; i < DEVICE_STORE_WORDS; ++i) { // Читаем все 20 слов слота из памяти Flash
            r[i] = s->memory[slot + i]; // Копируем слово из volatile-указателя Flash в локальный массив
            // Если слово отличается от стёртого состояния Flash (0xFFFFFFFF), взводим флаг
            // занятости слота
            used |= r[i] != 0xffffffffu;
        }
        // Если все 20 слов равны 0xFFFFFFFF, слот абсолютно чист — переходим к следующему
        if (!used) continue;
        // Любой непустой слот (даже битый при сбое питания) сдвигает указатель следующей свободной
        // записи дальше
        s->next_slot = slot + DEVICE_STORE_WORDS;

        // Отбрасываем запись, если не совпала сигнатура, версия формата (1), маркер фиксации COMMIT
        // или контрольная сумма CRC
        if (r[0] != STORE_MAGIC || ((r[1] & 0xFFFFu) != 1 && (r[1] & 0xFFFFu) != 2) || r[18] != STORE_COMMIT || r[17] != checksum(r)) continue;

        // Заполняем временную структуру базовыми значениями (чтобы инициализировать константы R0)
        device_config_defaults(&c);
        // Извлекаем 16-битные Holding-регистры, упакованные по два в словах r[2]..r[16]
        for (i = 0; i < HR_CHANNEL_MASK; ++i)
            // Чётные регистры берутся из младших 16 бит слова, нечётные — из старших 16 бит
            map[i] = (uint16_t)(r[2 + i / 2] >> (16u * (i % 2)));

        map[HR_CHANNEL_MASK] = (r[1] & 0xFFFFu) == 1 ?
            (map[HR_CHANNELS] <= DEVICE_BOARD_CHANNEL_COUNT ? (uint16_t)((1u << map[HR_CHANNELS]) - 1u) : 0) : (uint16_t)(r[1] >> 16);

        // В старших 16 битах 16-го слова хранятся битовые флаги режимов обработки
        flags = (uint16_t)(r[16] >> 16);
        // Если во флагах взведены неизвестные биты, считаем запись повреждённой
        if (flags & ~((1u << COIL_MEDIAN) | (1u << COIL_AVERAGE) | (1u << COIL_CALIBRATION))) continue;
        c.use_median = (uint8_t)((flags >> COIL_MEDIAN) & 1u); // Извлекаем флаг включения медианного фильтра
        // Извлекаем флаг включения скользящего среднего
        c.use_average = (uint8_t)((flags >> COIL_AVERAGE) & 1u);
        // Извлекаем флаг включения калибровочных поправок
        c.use_calibration = (uint8_t)((flags >> COIL_CALIBRATION) & 1u);

        // Декодируем массив регистров в физические величины с проверкой границ; при ошибке
        // пропускаем слот
        if (registers_decode(&c, map)) continue;
        if (device_config_valid(&c)) { // Выполняем финальную проверку целостности конфигурации
            // Обновляем выходную конфигурацию (каждая следующая валидная запись в журнале
            // перекрывает предыдущую)
            *out = c;
            found = 1; // Отмечаем, что актуальные настройки успешно найдены
        }
    }
    return found; // Возвращаем 1, если настройки восстановлены из Flash, либо 0, если сектор пуст/повреждён
}

// Подготовка образа записи в ОЗУ и запуск автомата сохранения в следующий свободный слот Flash
int device_store_save(device_store_t *s, const device_config_t *c)
{
    unsigned i; // Счётчик цикла
    // Временный массив для кодирования настроек в формат Holding-регистров
    uint16_t map[DEVICE_HOLDING_COUNT];
    // Собираем флаги фильтров и калибровки в одну битовую маску
    uint16_t flags = (uint16_t)((c->use_median << COIL_MEDIAN) | (c->use_average << COIL_AVERAGE) | (c->use_calibration << COIL_CALIBRATION));

    // Отказываем, если предыдущая запись ещё не завершена или текущая конфигурация невалидна
    if (s->state || !device_config_valid(c) || registers_encode(c, map)) return -1;
    // Проверяем, осталось ли в секторе Flash место под новый слот из 20 слов
    if (s->next_slot + DEVICE_STORE_WORDS > s->word_count) {
        s->error = 1; // Если журнал заполнен до конца сектора, выставляем флаг ошибки хранилища
        return -1; // Возвращаем код отказа
    }
    // Дополнительно убеждаемся, что все 20 слов целевого слота находятся в стёртом состоянии
    // (0xFFFFFFFF)
    for (i = 0; i < DEVICE_STORE_WORDS; ++i) {
        if (s->memory[s->next_slot + i] != 0xffffffffu) { // Если хотя бы одно слово в слоте уже было тронуто
            s->error = 1; // Фиксируем ошибку памяти
            return -1; // Прерываем запуск сохранения
        }
    }

    memset(s->record, 0, sizeof(s->record)); // Очищаем буфер подготовки записи в ОЗУ
    s->record[0] = STORE_MAGIC; // Слово 0: записываем сигнатуру заголовка 'PTC2'
    s->record[1] = 2u | (c->channel_mask << 16); // Версия 2 и маска каналов; размер слота и расположение CRC сохранены.
    // Упаковываем массив 16-битных регистров по два в 32-битные слова с индексами 2..16
    for (i = 0; i < HR_CHANNEL_MASK; ++i)
        // Чётный регистр ложится в младшее полуслово, нечётный — в старшее
        s->record[2 + i / 2] |= (uint32_t)map[i] << (16u * (i % 2));
    // В свободную старшую половину слова 16 помещаем битовую маску флагов Coils
    s->record[16] |= (uint32_t)flags << 16;
    // Слово 17: вычисляем и записываем 32-битную контрольную сумму по словам 0..16
    s->record[17] = checksum(s->record);
    // Слово 18: маркер завершения транзакции 'CFG2' (физически программируется самым последним)
    s->record[18] = STORE_COMMIT;
    s->record[19] = 0xffffffffu; // Слово 19: резервное выравнивающее слово (остаётся непрограммированным)

    s->index = 0; // Начинаем запись с нулевого слова буфера record
    s->error = 0; // Сбрасываем флаг ошибки перед стартом
    // Переводим автомат журнала в состояние 1 (готовность начать программирование очередного слова)
    s->state = 1;
    return 0; // Запрос на сохранение успешно принят в работу
}

// Пошаговый автомат записи слов журнала во Flash-память без блокировки главного цикла
void device_store_poll(device_store_t *s)
{
    if (s->state == 1) { // Состояние 1: Инициация аппаратной записи текущего 32-битного слова
        // Вызываем функцию старта записи слова во Flash; если она сразу вернула ошибку (-1)
        if (s->begin_word(s->context, s->next_slot + s->index, s->record[s->index])) {
            s->error = 1; // Выставляем флаг аппаратной ошибки сохранения
            s->state = 0; // Останавливаем автомат записи
            // Сдвигаем указатель за пределы испорченного слота, чтобы больше никогда в него не
            // писать
            s->next_slot += DEVICE_STORE_WORDS;
        } else { // Если программирование слова успешно запущено
            s->state = 2; // Переводим автомат в состояние 2 (ожидание снятия флага занятости Flash BSY)
        }
    } else if (s->state == 2) { // Состояние 2: Проверка завершения программирования текущего слова
        // Опрашиваем статус контроллера Flash (0 — занят, 1 — готово, -1 — ошибка)
        int result = s->poll_word(s->context);
        // Если контроллер Flash ещё программирует ячейку, сразу возвращаем управление в главный
        // цикл
        if (!result) return;
        // Если произошла аппаратная ошибка или прочитанное из Flash слово не совпадает с записанным
        // (ошибка верификации)
        if (result < 0 || s->memory[s->next_slot + s->index] != s->record[s->index]) {
            s->error = 1; // Фиксируем сбой записи
            s->state = 0; // Завершаем работу автомата
            s->next_slot += DEVICE_STORE_WORDS; // Пропускаем частично записанный слот
        // Если слово записалось верно, переходим к следующему; после записи слова 18 (STORE_COMMIT)
        // индекс достигает 19
        } else if (++s->index == 19) {
            // Все значимые слова (0..18), включая маркер фиксации, записаны — переводим автомат в
            // состояние покоя
            s->state = 0;
            // Продвигаем указатель на следующий чистый слот для будущих сохранений
            s->next_slot += DEVICE_STORE_WORDS;
        } else { // Если записаны ещё не все слова (индекс меньше 19)
            // Возвращаем автомат в состояние 1 для запуска записи следующего слова на следующем
            // проходе цикла
            s->state = 1;
        }
    }
}
