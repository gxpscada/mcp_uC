#include "device_rtc.h"
#include "device_calendar.h"
#include "device_board_stm32.h"

#define RTC_MAGIC 0x50545231u // Контрольная сигнатура ('PTR1' в ASCII) в backup-регистрах для проверки сохранности питания домена RTC
#define RTC_FAILED 0u // Состояние автомата: сбой запуска генератора или таймаут входа в режим инициализации
#define RTC_WAIT_CLOCK 1u // Состояние автомата: ожидание стабилизации тактового генератора LSE/LSI
#define RTC_WAIT_INIT 2u // Состояние автомата: ожидание подтверждения входа RTC в режим редактирования календаря (бит INITF)
#define RTC_READY 3u // Состояние автомата: часы настроены, идут и готовы к чтению/записи
#define RTC_CLOCK_TIMEOUT_MS 3000u // Максимальное время ожидания запуска часового кварца LSE (3 секунды)
#define RTC_INIT_TIMEOUT_MS 100u // Максимальное время ожидания установки аппаратного флага INITF (100 мс)
#define RTC_READ_ATTEMPTS 3u // Число повторных попыток чтения регистров при попадании на границу смены секунды

static uint8_t state; // Текущее состояние конечного автомата драйвера RTC
// Флаг: 1 — выполняется установка реального времени от пользователя, 0 — первичная техническая
// инициализация
static uint8_t writing;
static uint32_t since; // Метка времени (HAL_GetTick) начала текущего этапа ожидания для контроля таймаута
static uint32_t requested; // Буфер целевого значения времени Unix UTC для записи в регистры календаря
volatile uint8_t device_rtc_error; // Глобальный флаг аппаратной ошибки модуля RTC

// Перевод двузначного десятичного числа (0..99) в двоично-десятичный формат (BCD) для регистров RTC
static uint32_t bcd(unsigned v)
{
    // Десятки помещаем в старшую тетраду (умножение на 16), единицы — в младшую тетраду
    return (v / 10u) * 16u + v % 10u;
}

// Обратный перевод байта из двоично-десятичного формата (BCD) в обычное целое число
static uint8_t unbcd(uint32_t v)
{
    // Извлекаем старшую тетраду, умножаем на 10 и складываем с младшей тетрадой
    return (uint8_t)(((v >> 4) & 15u) * 10u + (v & 15u));
}

// Снятие аппаратной защиты от записи с регистров блока RTC
static void unlock(void)
{
    // Записываем первый обязательный ключ разблокировки (0xCA) в регистр Write Protection Register
    RTC->WPR = 0xca;
    RTC->WPR = 0x53; // Записываем второй обязательный ключ разблокировки (0x53) по документации STM32F4
}

// Аварийный останов автомата RTC при таймауте кварца или сбое конфигурации
static void fail(void)
{
    unlock(); // Разблокируем регистры RTC на случай, если защита была активна
    // Сбрасываем бит режима инициализации INIT, чтобы не оставлять часы остановленными
    RTC->ISR &= ~RTC_ISR_INIT;
    RTC->WPR = 0xff; // Запираем регистры RTC от случайной записи любым неключевым байтом (0xFF)
    state = RTC_FAILED; // Переводим автомат в состояние фатальной ошибки
    device_rtc_error = 1; // Выставляем глобальный флаг неисправности RTC для основного приложения
}

// Запуск неблокирующей инициализации домена резервного питания (Backup Domain) и генератора RTC
void device_rtc_init(void)
{
    __HAL_RCC_PWR_CLK_ENABLE(); // Включаем тактирование контроллера питания PWR в шине APB1
    // Устанавливаем бит DBP (Disable Backup Domain Write Protection), открывая доступ к RCC->BDCR и
    // регистрам RTC
    PWR->CR |= PWR_CR_DBP;
    state = RTC_WAIT_CLOCK; // Переводим автомат в режим ожидания стабилизации часового генератора
    writing = 0; // Помечаем, что это холодный старт, а не пользовательская установка времени
    since = HAL_GetTick(); // Засекаем время старта ожидания генератора
    device_rtc_error = 0; // Сбрасываем флаг ошибки RTC
#if DEVICE_RTC_USE_LSE // Если в конфигурации платы выбран внешний часовой кварц 32768 Гц
    // Включаем генератор внешнего низкочастотного кварца LSE в регистре управления Backup-доменом
    RCC->BDCR |= RCC_BDCR_LSEON;
#else // Если выбран внутренний RC-генератор микроконтроллера (~32 кГц)
    // Включаем внутренний низкочастотный генератор LSI в регистре управления/статуса RCC->CSR
    RCC->CSR |= RCC_CSR_LSION;
#endif
}

// Проверка занятости автомата RTC
int device_rtc_busy(void)
{
    // Возвращает 0 только когда часы полностью готовы к работе, иначе ненулевое значение
    return state != RTC_READY;
}

// Неблокирующий шаг автомата инициализации и записи календаря RTC (вызывается из главного цикла)
void device_rtc_poll(void)
{
    if (state == RTC_WAIT_CLOCK) { // Этап 1: Ожидание выхода генератора LSE или LSI на рабочий режим
        // Определяем код выбора источника тактирования в мультиплексоре RTCSEL (01b — LSE, 10b —
        // LSI)
        uint32_t source = DEVICE_RTC_USE_LSE ? RCC_BDCR_RTCSEL_0 : RCC_BDCR_RTCSEL_1;
        // Проверяем аппаратный бит стабилизации частоты выбранного генератора (LSERDY или LSIRDY)
        int ready = DEVICE_RTC_USE_LSE ? (RCC->BDCR & RCC_BDCR_LSERDY) != 0 : (RCC->CSR & RCC_CSR_LSIRDY) != 0;
        if (!ready) { // Если генератор ещё не стабилизировался
            // При превышении таймаута (3000 мс) фиксируем отказ кварца
            if ((uint32_t)(HAL_GetTick() - since) > RTC_CLOCK_TIMEOUT_MS) fail();
            return; // Иначе выходим до следующей итерации главного цикла, не задерживая программу
        }
        // Если в Backup-домене ранее уже был выбран другой источник тактирования (сменить его без
        // сброса BDRST нельзя)
        if ((RCC->BDCR & RCC_BDCR_RTCSEL) && (RCC->BDCR & RCC_BDCR_RTCSEL) != source) {
            fail(); // Фиксируем ошибку конфигурации тактирования
            return; // Завершаем работу функции
        }
        // Выбираем источник тактирования в битах RTCSEL и подаём тактирование на периферию RTC (бит
        // RTCEN)
        RCC->BDCR |= source | RCC_BDCR_RTCEN;
        // Если в нулевом backup-регистре уже записана сигнатура (делители и формат часов настроены
        // ранее)
        if (RTC->BKP0R == RTC_MAGIC) {
            state = RTC_READY; // Сразу переводим автомат в готовое состояние, сохраняя ход часов
            return; // Выходим
        }
        // Задаём техническую начальную дату 01.01.2000 00:00:00 UTC для первичного запуска
        // счётчиков
        requested = 946684800u;
        writing = 0; // Указываем, что время ещё не синхронизировано с реальным UTC
        unlock(); // Разблокируем защиту записи регистров RTC (ключ 0xCA, 0x53)
        // Выставляем бит INIT, запрашивая остановку счётчика для настройки делителей и календаря
        RTC->ISR |= RTC_ISR_INIT;
        since = HAL_GetTick(); // Засекаем время начала ожидания входа в режим инициализации
        state = RTC_WAIT_INIT; // Переводим автомат на этап ожидания флага INITF
    // Этап 2: Ожидание подтверждения остановки счётчиков и запись новых значений даты/времени
    } else if (state == RTC_WAIT_INIT) {
        // Структура для разложения Unix-времени на год, месяц, день, часы, минуты и секунды
        device_calendar_t c;
        // Проверяем аппаратный флаг INITF (подтверждение того, что регистры календаря открыты для
        // обновления)
        if (!(RTC->ISR & RTC_ISR_INITF)) {
            // Если флаг не поднялся за 100 мс, фиксируем аппаратную ошибку RTC
            if ((uint32_t)(HAL_GetTick() - since) > RTC_INIT_TIMEOUT_MS) fail();
            return; // Иначе ждём следующего прохода цикла
        }
        // Конвертируем запрошенное время из секунд Unix в календарную структуру
        (void)device_epoch_to_calendar(requested, &c);
        // Задаём 24-часовой формат (FMT=0) и включаем бит BYPSHAD (чтение счётчиков напрямую в
        // обход теневых регистров)
        RTC->CR = RTC_CR_BYPSHAD;
        // Настраиваем предделители: асинхронный PREDIV_A = 127 (делит на 128) и синхронный PREDIV_S
        // = 255 для LSE (32768/128/256 = 1 Гц) или 249 для LSI (32000/128/250 = 1 Гц)
        RTC->PRER = (127u << 16) | (DEVICE_RTC_USE_LSE ? 255u : 249u);
        // Упаковываем часы, минуты и секунды в формате BCD и записываем одним словом в регистр
        // времени RTC->TR
        RTC->TR = (bcd(c.hour) << 16) | (bcd(c.minute) << 8) | bcd(c.second);
        // Упаковываем год (00..99), день недели, месяц и число в формате BCD в регистр даты RTC->DR
        RTC->DR = (bcd(c.year - 2000u) << 16) | ((uint32_t)c.weekday << 13) | (bcd(c.month) << 8) | bcd(c.day);
        // Сбрасываем бит INIT — часы выходят из режима настройки и возобновляют счёт
        RTC->ISR &= ~RTC_ISR_INIT;
        // Записываем сигнатуру в BKP0R (признак того, что предделители и структура RTC
        // инициализированы)
        RTC->BKP0R = RTC_MAGIC;
        // Во второй регистр BKP1R пишем сигнатуру только если время было явно установлено
        // пользователем по команде SetRTC
        RTC->BKP1R = writing ? RTC_MAGIC : 0;
        RTC->WPR = 0xff; // Включаем обратно аппаратную защиту регистров RTC от случайной перезаписи
        state = RTC_READY; // Переводим автомат в рабочее состояние готовности
    }
}

// Запрос на установку нового времени UTC в аппаратные часы
int device_rtc_set(uint32_t epoch)
{
    device_calendar_t c; // Временная структура для предварительной проверки даты
    // Если переданный штамп времени выходит за пределы 2000..2099 годов, сразу возвращаем ошибку
    if (device_epoch_to_calendar(epoch, &c)) return -1;
    if (state != RTC_READY) return -1; // Если автомат RTC сейчас занят или неисправен, отклоняем запрос
    requested = epoch; // Сохраняем новое значение времени для последующей записи в функции poll
    writing = 1; // Указываем, что выполняется достоверная установка времени от хоста
    since = HAL_GetTick(); // Фиксируем время начала входа в режим редактирования
    unlock(); // Снимаем защиту от записи с регистров RTC
    RTC->ISR |= RTC_ISR_INIT; // Запрашиваем вход часов в режим инициализации (бит INIT)
    state = RTC_WAIT_INIT; // Переводим автомат в состояние ожидания флага INITF
    return 0; // Запрос принят, фактическая запись завершится в ближайшем вызове device_rtc_poll()
}

// Когерентное чтение текущего времени UTC с точностью до миллисекунд из регистров RTC
int device_rtc_get(uint32_t *epoch, uint16_t *ms)
{
    unsigned attempt; // Счётчик попыток согласованного чтения
    *epoch = 0; // По умолчанию обнуляем выходные секунды
    *ms = 0; // По умолчанию обнуляем выходные миллисекунды
    // Если часы не готовы или время ни разу не устанавливалось пользователем (нет маркера в BKP1R),
    // возвращаем -1
    if (state != RTC_READY || RTC->BKP1R != RTC_MAGIC) return -1;

    // Делаем до 3 попыток чтения на случай попадания ровно на фронт смены секунды
    for (attempt = 0; attempt < RTC_READ_ATTEMPTS; ++attempt) {
        // Первое чтение регистра подсекундного вычитающего счётчика (Sub Second Register)
        uint32_t ss1 = RTC->SSR;
        uint32_t tr = RTC->TR; // Чтение регистра времени (часы, минуты, секунды)
        uint32_t dr = RTC->DR; // Чтение регистра даты (год, месяц, день)
        uint32_t ss2 = RTC->SSR; // Повторное чтение подсекундного счётчика после чтения TR и DR
        device_calendar_t c; // Структура для сборки прочитанной даты

        // Так как счётчик SSR считает вниз (от PREDIV_S до 0), условие ss2 > ss1 означает, что во
        // время чтения произошёл перескок секунды — повторяем чтение заново
        if (ss2 > ss1) continue;
        // Извлекаем BCD-код года из битов 23..16 регистра DR и прибавляем базовый 2000 год
        c.year = (uint16_t)(2000u + unbcd((dr >> 16) & 0xff));
        // Извлекаем BCD-код месяца из битов 12..8 регистра DR (отсекая маской 0x1F биты дня недели)
        c.month = unbcd((dr >> 8) & 0x1f);
        c.day = unbcd(dr & 0x3f); // Извлекаем BCD-код числа месяца из младших битов 5..0 регистра DR
        c.hour = unbcd((tr >> 16) & 0x3f); // Извлекаем BCD-код часов из битов 21..16 регистра TR
        c.minute = unbcd((tr >> 8) & 0x7f); // Извлекаем BCD-код минут из битов 14..8 регистра TR
        c.second = unbcd(tr & 0x7f); // Извлекаем BCD-код секунд из битов 6..0 регистра TR
        // Переводим собранную дату в секунды Unix UTC; при ошибке возвращаем -1
        if (device_calendar_to_epoch(&c, epoch)) return -1;
        // Вычисляем прошедшую долю секунды в мс по формуле: (PREDIV_S - SSR) * 1000 / (PREDIV_S +
        // 1)
        *ms = (uint16_t)(((RTC->PRER & 0x7fff) - ss1) * 1000u / ((RTC->PRER & 0x7fff) + 1u));
        return 0; // Согласованный снимок времени успешно получен
    }
    return -1; // Если за 3 попытки не удалось прочитать непротиворечивые значения, возвращаем ошибку
}
