#include "device_calendar.h"

// Проверка года на високосность по григорианскому календарю
static unsigned leap(unsigned y)
{
    // Год високосный, если он кратен 4, но не кратен 100 (за исключением кратных 400)
    return y % 4 == 0 && (y % 100 != 0 || y % 400 == 0);
}

// Получение количества дней в конкретном месяце заданного года
static unsigned days(unsigned y, unsigned m)
{
    // Базовая таблица длительности месяцев с января по декабрь для невисокосного года
    static const uint8_t d[] = {31, 28, 31, 30, 31, 30, 31, 31, 30, 31, 30, 31};
    // Возвращаем число дней из таблицы, прибавляя 1 день в феврале (m == 2), если год високосный
    return d[m - 1] + (m == 2 ? leap(y) : 0);
}

// Преобразование 32-битного Unix-времени (секунды с 01.01.1970) в структуру календаря
int device_epoch_to_calendar(uint32_t epoch, device_calendar_t *c)
{
    // Целое количество полных суток, прошедших с 1 января 1970 года (86400 секунд в сутках)
    uint32_t d = epoch / 86400u;
    uint32_t rest = epoch % 86400u; // Остаток секунд внутри текущих неполных суток
    unsigned y = 1970; // Начальный год отсчёта эпохи Unix
    unsigned m = 1; // Начальный месяц (1 — январь)
    // Разрешаем только даты с 01.01.2000 00:00:00 по 31.12.2099 23:59:59 (диапазон аппаратного RTC
    // STM32)
    if (epoch < 946684800u || epoch > 4102444799u) return -1;
    // Вычисляем день недели от 1 (Пн) до 7 (Вс), учитывая, что 01.01.1970 был четвергом (+3)
    c->weekday = (uint8_t)((d + 3u) % 7u + 1u);
    while (d >= 365u + leap(y)) { // Пока оставшееся число дней больше или равно длине текущего года y
        d -= 365u + leap(y); // Вычитаем количество дней в году (365 или 366)
        ++y; // Переходим к следующему году
    }
    while (d >= days(y, m)) { // Пока оставшееся число дней превышает длину текущего месяца m
        d -= days(y, m); // Вычитаем дни полного месяца
        ++m; // Переходим к следующему месяцу
    }
    c->year = (uint16_t)y; // Записываем найденный год (2000..2099)
    c->month = (uint8_t)m; // Записываем найденный месяц (1..12)
    // Записываем число месяца (прибавляем 1, так как дни месяца нумеруются с 1, а не с 0)
    c->day = (uint8_t)(d + 1);
    c->hour = (uint8_t)(rest / 3600u); // Вычисляем часы делением секунд внутри суток на 3600
    c->minute = (uint8_t)((rest % 3600u) / 60u); // Из остатка часа выделяем полные минуты делением на 60
    c->second = (uint8_t)(rest % 60u); // Остаток от деления на 60 даёт секунды текущей минуты
    return 0; // Возвращаем 0 — преобразование выполнено успешно
}

// Обратное преобразование календарной даты и времени в секунды Unix UTC
int device_calendar_to_epoch(const device_calendar_t *c, uint32_t *epoch)
{
    unsigned y; // Счётчик лет для суммирования прошедших суток
    unsigned m; // Счётчик месяцев
    uint32_t d = 0; // Накопитель общего числа полных дней с 01.01.1970
    // Проверяем, что год входит в 2000..2099, а месяц — в 1..12
    if (c->year < 2000 || c->year > 2099 || c->month < 1 || c->month > 12 ||
        // Проверяем корректность числа месяца (с учётом високосности) и времени суток
        c->day < 1 || c->day > days(c->year, c->month) || c->hour > 23 || c->minute > 59 || c->second > 59) return -1;
    // Проходим в цикле все полные годы от 1970 до года, предшествующего текущему
    for (y = 1970; y < c->year; ++y)
        d += 365u + leap(y); // Прибавляем 365 или 366 дней за каждый полный прошедший год
    for (m = 1; m < c->month; ++m) // Проходим все полные месяцы текущего года до заданного месяца
        d += days(c->year, m); // Прибавляем количество дней в каждом прошедшем месяце
    // Прибавляем полные прошедшие сутки текущего месяца (текущий день ещё не закончился, поэтому
    // -1)
    d += c->day - 1u;
    // Переводим дни, часы и минуты в секунды и записываем итоговый штамп времени
    *epoch = d * 86400u + (uint32_t)c->hour * 3600u + (uint32_t)c->minute * 60u + c->second;
    return 0; // Возвращаем 0 — дата корректна, время рассчитано
}
