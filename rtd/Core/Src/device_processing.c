#include "device_processing.h"
#include <math.h>
#include <string.h>

#define CVD_A 3.9083e-3 // Коэффициент A уравнения Каллендара — Ван Дюзена для платиновых ТС по МЭК 60751 (ГОСТ 6651)
#define CVD_B (-5.775e-7) // Коэффициент B уравнения Каллендара — Ван Дюзена
#define CVD_C (-4.183e-12) // Коэффициент C (используется только при отрицательных температурах T < 0 °C)
#define CVD_MIN_C (-200.0) // Нижняя граница рабочего диапазона температур модели (-200 °C)
#define CVD_MAX_C 850.0 // Верхняя граница рабочего диапазона температур модели (+850 °C)
#define CVD_ITERATIONS 32u // Фиксированное число итераций метода бисекции для отрицательных температур
#define ADC_RAW_MAX 32767u // Максимальное значение 15-битного кода АЦП микросхемы MAX31865 (2^15 - 1)
#define ADC_Q1_MAX 65534 // Максимальное допустимое значение кода АЦП в формате с фиксированной точкой Q1 (32767 * 2)
#define ADC_Q1_DIVISOR 65536.0f // Делитель для перевода кода Q1 в отношение сопротивлений R/Rref (2^16)

// Полный сброс истории медианного и усредняющего фильтров одного канала
void device_filter_reset(device_filter_t *f)
{
    memset(f, 0, sizeof(*f)); // Обнуляем массивы задержки, индексы записи, счётчики заполнения и сумму
}

// Проверка корректности параметров фильтрации и физических номиналов канала
int device_filter_valid(const device_processing_settings_t *s)
{
    // Проверяем, что указатель не NULL и окно медианы равно 3, 5 или 7
    return s && (s->median_window == 3 || s->median_window == 5 || s->median_window == 7) &&
        // Проверяем, что окно скользящего среднего является степенью двойки: 2, 4,
        (s->average_window == 2 || s->average_window == 4 ||
         s->average_window == 8 || s->average_window == 16) && // 8 или 16 отсчётов
        // Номинал датчика R0 и опорное сопротивление Rref должны быть конечными числами больше нуля
        isfinite(s->r0) && s->r0 > 0 && isfinite(s->rref) && s->rref > 0 &&
        // Калибровочный множитель наклона k также должен быть конечным и строго положительным
        isfinite(s->gain) && s->gain > 0;
}

// Прямая функция Каллендара — Ван Дюзена: вычисление относительного сопротивления R(t)/R0 по
// температуре t
static double ratio(double t)
{
    // Квадратичная часть: 1 + A*t + B*t^2 (действует во всём диапазоне)
    return 1.0 + CVD_A * t + CVD_B * t * t +
        // При t < 0 °C добавляется слагаемое четвёртой степени C*(t - 100)*t^3
        (t < 0 ? CVD_C * (t - 100) * t * t * t : 0);
}

// Обратное преобразование: расчёт температуры платинового термосопротивления по измеренному
// сопротивлению
int device_cvd_temperature(float resistance, float r0, float *temperature)
{
    double r; // Относительное сопротивление датчика R / R0
    double t; // Искомая температура в градусах Цельсия
    // Отклоняем вызов при некорректных аргументах
    if (!temperature || !isfinite(resistance) || !isfinite(r0) || r0 <= 0) return -1;
    r = (double)resistance / r0; // Нормируем измеренное сопротивление к номиналу датчика при 0 °C
    // Если сопротивление выходит за физические границы диапазона -200..+850 °C, возвращаем ошибку
    if (r < ratio(CVD_MIN_C) || r > ratio(CVD_MAX_C)) return -1;

    if (r >= 1) { // Если сопротивление не меньше R0 (область неотрицательных температур T >= 0 °C)
        // Решаем квадратное уравнение 1 + A*t + B*t^2 = r через домножение на сопряжённое
        // (исключает потерю точности при вычитании близких чисел при малых t)
        t = 2.0 * (r - 1.0) / (CVD_A + sqrt(CVD_A * CVD_A + 4 * CVD_B * (r - 1)));
    // Если r < 1 (область отрицательных температур от -200 до 0 °C, где действует полином 4-й
    // степени)
    } else {
        double lo = CVD_MIN_C; // Левая граница интервала поиска корня (-200 °C)
        double hi = 0; // Правая граница интервала поиска корня (0 °C)
        unsigned i; // Номер шага поиска.
        // Ограничиваем поиск 32 шагами, чтобы время расчёта было предсказуемым. Ширина интервала
        // поиска не равна точности измерения.
        for (i = 0; i < CVD_ITERATIONS; ++i) {
            double mid = (lo + hi) * 0.5; // Находим середину текущего температурного интервала
            // Так как функция R(t) строго монотонна, при значении меньше целевого сдвигаем левую
            // границу
            if (ratio(mid) < r) lo = mid;
            else hi = mid; // Иначе сдвигаем правую границу к середине
        }
        t = (lo + hi) * 0.5; // В качестве ответа берём середину финального суженного интервала
    }
    *temperature = (float)t; // Записываем вычисленную температуру в формате float по указателю
    return 0; // Успешное завершение расчёта
}

// Полный цикл обработки одного отсчёта АЦП: медианный фильтр -> скользящее среднее -> поправка b ->
// расчёт Ом -> CVD -> коэффициент k
int device_process(device_filter_t *f, const device_processing_settings_t *s, uint16_t raw, device_processed_t *out)
{
    uint16_t value = raw; // Текущее рабочее значение кода АЦП (проходит через ступени фильтрации)
    // Значение кода АЦП в формате с фиксированной точкой Q31.1 (удвоенный код с сохранением 0.5
    // МЗР)
    uint32_t q1;
    // 64-битная знаковая переменная для безопасного прибавления калибровочного смещения без
    // переполнения
    int64_t corrected;
    unsigned i; // Внешний индекс для сортировки вставками
    unsigned j; // Внутренний индекс для сортировки вставками

    // Обнуляем выходную структуру (флаг valid = 0 до успешного прохождения всех этапов)
    memset(out, 0, sizeof(*out));
    // Проверяем валидность настроек и то, что сырой код не превышает 15 бит (32767)
    if (!device_filter_valid(s) || raw > ADC_RAW_MAX) return -1;

    if (s->use_median) { // Если включена ступень медианной фильтрации импульсных помех
        uint16_t sorted[7]; // Локальный буфер для сортировки окна (максимальный размер окна — 7 элементов)
        // Записываем новый сырой отсчёт в текущую позицию кольцевого буфера медианы
        f->median[f->median_pos] = raw;
        // Сдвигаем указатель кольцевого буфера по модулю длины окна
        f->median_pos = (uint8_t)((f->median_pos + 1u) % s->median_window);
        // Увеличиваем счётчик накопленных элементов до тех пор, пока окно не заполнится
        if (f->median_count < s->median_window) ++f->median_count;
        // Если окно ещё не заполнено целиком, возвращаем 0 (режим прогрева фильтра FILTER_WARMUP)
        if (f->median_count < s->median_window) return 0;
        // Копируем элементы кольцевого буфера во временный массив для сортировки
        memcpy(sorted, f->median, s->median_window * sizeof(uint16_t));
        // Сортируем временный массив методом простых вставок (Insertion Sort)
        for (i = 1; i < s->median_window; ++i) {
            uint16_t x = sorted[i]; // Выбираем текущий вставляемый элемент
            for (j = i; j && sorted[j - 1] > x; --j) // Пока предыдущие элементы больше выбранного x
                sorted[j] = sorted[j - 1]; // Сдвигаем большие элементы на одну позицию вправо
            sorted[j] = x; // Вставляем элемент x на найденное упорядоченное место
        }
        // Берём центральный элемент отсортированного массива (медиану выборки)
        value = sorted[s->median_window / 2];
    }

    // Переводим значение после медианы в формат Q1 (умножаем на 2, младший бит отвечает за 0.5
    // отсчёта АЦП)
    q1 = (uint32_t)value * 2u;

    if (s->use_average) { // Если включена ступень фильтра скользящего среднего
        // Вычисляем величину битового сдвига для получения (2 * sum / N):
        unsigned shift = s->average_window == 2 ? 0u : s->average_window == 4 ? 1u :
                         // для N=2 сдвиг 0, для N=4 сдвиг 1, для N=8 сдвиг 2, для N=16 сдвиг 3
                         s->average_window == 8 ? 2u : 3u;
        // Вычитаем из бегущей суммы самый старый элемент, который сейчас будет перезаписан
        f->sum -= f->average[f->average_pos];
        // Записываем на его место в кольцевой буфер новое значение после медианного фильтра
        f->average[f->average_pos] = value;
        f->sum += value; // Прибавляем новое значение к бегущей сумме окна
        // Продвигаем индекс кольцевого буфера усреднения по модулю размера окна
        f->average_pos = (uint8_t)((f->average_pos + 1u) % s->average_window);
        // Отслеживаем количество накопленных отсчётов до заполнения окна
        if (f->average_count < s->average_window) ++f->average_count;
        // Пока окно скользящего среднего не набралось полностью, возвращаем 0 (прогрев фильтра)
        if (f->average_count < s->average_window) return 0;
        // Делим сумму на N/2 битовым сдвигом вправо, сразу получая среднее значение в формате Q1 с
        // точностью 0.5 МЗР
        q1 = f->sum >> shift;
    }

    out->adc_q1 = q1; // Сохраняем отфильтрованный код АЦП в формате Q1 до внесения калибровочного смещения
    // Если калибровка включена, прибавляем смещение b (умноженное на 2 для соответствия масштабу
    // Q1)
    corrected = (int64_t)q1 + (s->use_calibration ? (int64_t)s->adc_offset * 2 : 0);
    // Если после поправки код вышел за пределы 15-битной шкалы АЦП (0..65534 в Q1), фиксируем
    // ошибку диапазона
    if (corrected < 0 || corrected > ADC_Q1_MAX) return -1;
    out->corrected_q1 = (uint32_t)corrected; // Сохраняем скорректированный код Q1 в структуру результата
    // Переводим код в физическое сопротивление: R = (Код_Q1 / 65536) * Rref
    out->resistance = (float)corrected * (s->rref / ADC_Q1_DIVISOR);
    // Вычисляем температуру по формуле Каллендара — Ван Дюзена; при выходе за -200..+850 °C
    // возвращаем -1
    if (device_cvd_temperature(out->resistance, s->r0, &out->temperature)) return -1;
    // Если калибровка активна, домножаем рассчитанную температуру на корректирующий коэффициент
    // наклона k
    if (s->use_calibration) out->temperature *= s->gain;
    // Дополнительная проверка на отсутствие переполнения float (Inf/NaN)
    if (!isfinite(out->temperature)) return -1;
    out->valid = 1; // Поднимаем флаг достоверности рассчитанных физических величин
    return 1; // Возвращаем 1 — обработка отсчёта успешно завершена
}
