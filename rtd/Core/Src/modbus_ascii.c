#include "modbus_ascii.h"
#include <string.h>

// Вычисление контрольной суммы CRC-16 по стандарту Modbus (полином 0xA001, начальное значение
// 0xFFFF)
uint16_t modbus_crc16(const uint8_t *data, size_t n)
{
    uint16_t crc = 0xffff; // Инициализируем 16-битный сдвиговый регистр CRC единицами
    size_t i; // Номер байта.
    for (i = 0; i < n; ++i) { // Проходим последовательно по всем n байтам входного буфера
        unsigned j; // Счётчик битов внутри одного байта (от 0 до 7)
        crc ^= data[i]; // Накладываем очередной байт данных по XOR на младший байт регистра CRC
        for (j = 0; j < 8; ++j) // Обрабатываем каждый из 8 битов текущего байта
            // Сдвигаем CRC вправо на 1 бит; если выдвинутый младший бит был равен 1, выполняем XOR
            // с реверсивным полиномом 0xA001
            crc = (uint16_t)((crc >> 1) ^ ((crc & 1u) ? 0xa001u : 0));
    }
    // Возвращаем итоговую 16-битную контрольную сумму (при проверке пакета вместе с его CRC
    // исправный кадр даёт 0)
    return crc;
}

// Вычисление продольной контрольной суммы LRC (Longitudinal Redundancy Check) для кадра Modbus
// ASCII
uint8_t modbus_lrc(const uint8_t *data, size_t n)
{
    uint8_t sum = 0; // Накопитель суммы байтов по модулю 256
    while (n--) // Пока не обошли все байты двоичного пакета (адрес + PDU)
        // Складываем байты в 8-битную переменную с естественным переполнением (отбрасыванием
        // переносов выше 8 бит)
        sum = (uint8_t)(sum + *data++);
    // Возвращаем дополнительный код суммы (инверсия битов + 1), чтобы сумма всех байтов вместе с
    // LRC давала 0x00
    return (uint8_t)(0u - sum);
}

// Кодирование двоичного пакета (Адрес + PDU) в текстовый кадр Modbus ASCII вида ":XX...XX\r\n"
size_t modbus_ascii_encode(const uint8_t *data, size_t n, uint8_t *out, size_t capacity)
{
    // Таблица перевода 4-битной тетрады (0..15) в печатный ASCII-символ верхнего регистра
    static const char hex[] = "0123456789ABCDEF";
    size_t i; // Номер кодируемого байта.
    size_t used = 0; // Счётчик записанных в выходной буфер ASCII-символов
    uint8_t lrc; // Вычисленный байт контрольной суммы LRC

    // Проверяем минимальную длину (адрес + функция), лимит ADU и достаточность места в буфере под
    // ':', 2*(n+1) HEX-символов и "\r\n"
    if (n < 2 || n >= MB_ADU_MAX || capacity < 2u * (n + 1u) + 3u) return 0;
    lrc = modbus_lrc(data, n); // Рассчитываем байт контрольной суммы LRC по исходным двоичным данным
    out[used++] = ':'; // Записываем стартовый маркер кадра Modbus ASCII (символ двоеточия, 0x3A)
    // Проходим по всем n байтам пакета плюс ещё один шаг (i == n) для дописывания байта LRC в конец
    for (i = 0; i <= n; ++i) {
        // На последнем шаге цикла берём байт LRC, на остальных — очередной байт данных
        uint8_t value = i == n ? lrc : data[i];
        // Выделяем старшую тетраду байта (биты 7..4) и преобразуем её в первый HEX-символ
        out[used++] = (uint8_t)hex[value >> 4];
        // Выделяем младшую тетраду байта (биты 3..0) и преобразуем её во второй HEX-символ
        out[used++] = (uint8_t)hex[value & 15u];
    }
    out[used++] = '\r'; // Записываем первый символ конца кадра — возврат каретки (CR, 0x0D)
    out[used++] = '\n'; // Записываем второй символ конца кадра — перевод строки (LF, 0x0A)
    return used; // Возвращаем итоговую длину сформированного ASCII-пакета в байтах
}

// Сборка 16-битного слова из двух байтов в сетевом порядке Big-Endian (старший байт первый)
static uint16_t be16(const uint8_t *p)
{
    // Сдвигаем нулевой байт в старшую половину слова и объединяем по ИЛИ с первым байтом
    return (uint16_t)(((uint16_t)p[0] << 8) | p[1]);
}

// Укладка 16-битного слова в массив из двух байтов в порядке Big-Endian (старший байт по меньшему
// адресу)
static void put16(uint8_t *p, uint16_t v)
{
    p[0] = (uint8_t)(v >> 8); // Записываем старший байт числа в нулевую ячейку
    p[1] = (uint8_t)v; // Записываем младший байт числа в первую ячейку
}

// Начальная инициализация контекста Modbus ASCII и привязка callback-функций чтения/записи карты
// регистров
void modbus_ascii_init(modbus_ascii_t *m, uint8_t address, void *ctx, mb_read_fn read, mb_write_fn write)
{
    memset(m, 0, sizeof(*m)); // Обнуляем все буферы, индексы очереди и счётчики диагностики транспорта
    m->address = address; // Сохраняем собственный сетевой адрес ведомого устройства (Slave ID)
    m->context = ctx; // Сохраняем указатель на прикладной контекст (device_control_t)
    m->read = read; // Привязываем функцию чтения адресных пространств
    m->write = write; // Привязываем функцию записи адресных пространств
}

// Приём USB-фрагмента в кольцевой буфер. Здесь измеряется пауза между callback приёма, а не между
// символами на проводе.
void modbus_ascii_receive(modbus_ascii_t *m, const uint8_t *p, size_t n, uint32_t ms)
{
    uint16_t head = m->head; // Читаем локальную копию индекса головы записи кольцевого буфера
    size_t i; // Счётчик байтов внутри принятого USB-пакета
    // Вычисляем флаг разрыва кадра: 1, если с момента прошлого приёма прошло больше допустимого
    // таймаута
    uint8_t gap = (uint8_t)(m->received_once && (uint32_t)(ms - m->last_rx_ms) >= MB_CHARACTER_TIMEOUT_MS);

    // Если пришёл пустой пакет (0 байт), ничего не делаем и не обновляем время последнего приёма
    if (!n) return;
    // Проверяем, помещается ли весь принятый фрагмент в свободное место кольцевого буфера
    if (n > MB_RX_SIZE - 1u - (uint16_t)(head - m->tail)) {
        ++m->overflows; // Считаем переполнение: весь новый фрагмент будет отброшен.
        m->reset_requested = 1; // Выставляем флаг полного сброса текущего обмена для главного цикла
        return; // Отбрасываем пакет целиком и выходим из прерывания
    }
    for (i = 0; i < n; ++i) { // Записываем каждый принятый байт в кольцевой буфер
        // Вычисляем индекс ячейки в массиве (быстрое взятие остатка по модулю степени двойки
        // MB_RX_SIZE)
        unsigned slot = head & (MB_RX_SIZE - 1u);
        m->ring[slot] = p[i]; // Записываем сам принятый символ в кольцевой буфер данных
        // Перед первым байтом фрагмента отмечаем слишком долгую паузу после предыдущего
        // USB-фрагмента.
        m->gap[slot] = (uint8_t)(i == 0 && gap);
        ++head; // Продвигаем локальный указатель головы записи
    }
    // Помечаем, что хотя бы один пакет за время работы уже был принят (разрешает проверку пауз gap)
    m->received_once = 1;
    m->last_rx_ms = ms; // Запоминаем время получения этого USB-фрагмента.
    m->head = head; // Публикуем обновлённый индекс головы для чтения в главном цикле
}

// Запрос сброса состояния парсера и очередей при физическом отключении USB
void modbus_ascii_disconnect(modbus_ascii_t *m)
{
    m->reset_requested = 1; // Просим главный цикл сбросить обмен при следующем вызове modbus_ascii_poll.
}

// Разбор и выполнение проверенного двоичного запроса PDU и формирование ответного кадра
static void execute(modbus_ascii_t *m, int replay)
{
    // Указатель на буфер принятого двоичного запроса (q[0] — адрес, q[1] — код функции)
    const uint8_t *q = m->request;
    uint8_t r[MB_ADU_MAX]; // Локальный буфер для сборки двоичного ответа до его перевода в ASCII
    uint8_t fc = q[1]; // Извлекаем код функции Modbus (Function Code)
    uint16_t values[MB_READ_MAX]; // Временный массив 16-битных значений для обмена с картой регистров
    uint16_t address = 0; // Начальный адрес запрашиваемого регистра или бита
    uint16_t count = 0; // Количество запрашиваемых элементов (или значение для одиночной записи)
    unsigned i; // Индекс цикла упаковки/распаковки данных
    unsigned bytes; // Количество байтов полезных данных в поле Byte Count
    unsigned space; // Идентификатор целевого адресного пространства (Coils, Discrete, Holding, Input)
    size_t n = 0; // Итоговая длина сформированного двоичного ответа в байтах
    int error = 0; // Код исключения Modbus (0 — нет ошибки)
    uint8_t armed = m->stream_armed;
    int broadcast = q[0] == 0; // Признак широковещательного запроса (адрес 0x00)

    if (!replay) {
        m->stream_armed = 0;
        m->stream_active = 0;
        m->response_is_stream = 0;
    }
    // Если пакет адресован другому устройству и не является широковещательным, молча игнорируем его
    if (q[0] != m->address && !broadcast) return;
    // Все стандартные команды этого профиля имеют длину минимум 6 байт (Адрес + FC + 2 байта адреса
    // + 2 байта количества/значения)
    if (m->request_length >= 6) {
        address = be16(q + 2); // Считываем 16-битный начальный адрес регистра из байтов 2 и 3
        // Считываем 16-битное поле количества (или значения одиночной записи) из байтов 4 и 5
        count = be16(q + 4);
    }
    r[0] = q[0]; // Копируем адрес устройства в заголовок ответа
    r[1] = fc; // Копируем код функции в заголовок ответа
    if (!replay) ++m->requests; // Увеличиваем диагностический счётчик принятых запросов к нашему адресу

    switch (fc) { // Выбираем логику обработки по коду функции Modbus
    case MB_FC_READ_COILS: // 0x01: Чтение флагов Coils
    case MB_FC_READ_DISCRETE: // 0x02: Чтение дискретных входов Discrete Inputs
    case MB_FC_READ_HOLDING: // 0x03: Чтение регистров хранения Holding Registers
    case MB_FC_READ_INPUT: { // 0x04: Чтение входных регистров Input Registers
        if (m->request_length != 6) { // Запрос чтения обязан состоять ровно из 6 байт
            error = MB_ILLEGAL_VALUE; // При неверной длине кадра возвращаем ошибку данных
            break;
        }
        if (broadcast) return; // Широковещательные запросы чтения бессмысленны и по стандарту игнорируются
        // Проверяем, что количество элементов больше 0, не превышает лимит буфера и не переполняет
        // 16-битное адресное пространство
        if (!count || count > MB_READ_MAX || (uint32_t)address + count > MB_ADDRESS_SPACE) {
            error = MB_ILLEGAL_VALUE; // Выставляем код исключения Illegal Data Value
        } else {
            // Определяем тип пространства для передачи в callback чтения: Coils,
            space = fc == MB_FC_READ_COILS ? MB_COILS :
                    fc == MB_FC_READ_DISCRETE ? MB_DISCRETE : // Discrete Inputs,
                    fc == MB_FC_READ_HOLDING ? MB_HOLDING : MB_INPUT; // Holding Registers или Input Registers
            // Запрашиваем данные у прикладной карты регистров
            error = m->read(m->context, space, address, count, values);
            if (!error) { // Если чтение карты прошло без ошибок
                // Считаем размер ответа в байтах: для битовых функций округляем вверх до целых
                // байтов, для регистров умножаем на 2
                bytes = fc <= MB_FC_READ_DISCRETE ? (count + 7u) / 8u : count * 2u;
                r[2] = (uint8_t)bytes; // Записываем поле счётчика байтов (Byte Count) в 3-й байт ответа
                memset(r + 3, 0, bytes); // Обнуляем область полезных данных ответа перед побитовой упаковкой
                for (i = 0; i < count; ++i) { // Упаковываем каждый прочитанный элемент в выходной буфер
                    if (fc <= MB_FC_READ_DISCRETE) // Если читались биты (Coils или Discrete Inputs)
                        // Укладываем биты по 8 штук в байт от младшего к старшему
                        r[3 + i / 8] |= (uint8_t)((values[i] != 0) << (i % 8));
                    else // Если читались 16-битные регистры
                        // Укладываем каждое 16-битное слово в формате Big-Endian
                        put16(r + 3 + i * 2, values[i]);
                }
                // Общая длина ответа равна 3 байтам заголовка (Адрес, FC, ByteCount) плюс байты
                // данных
                n = 3u + bytes;
            }
        }
        break;
    }

    case MB_FC_WRITE_COIL: // 0x05: Запись одного бита Coil
    case MB_FC_WRITE_REGISTER: { // 0x06: Запись одного 16-битного регистра Holding Register
        if (m->request_length != 6) { // Запрос одиночной записи должен иметь длину строго 6 байт
            error = MB_ILLEGAL_VALUE; // При отклонении длины фиксируем ошибку
            break;
        }
        // Для функции 0x05 стандарт Modbus допускает только значения 0x0000 (OFF) и 0xFF00 (ON)
        if (fc == MB_FC_WRITE_COIL && count != 0 && count != MB_COIL_ON) {
            error = MB_ILLEGAL_VALUE; // Любое другое число в поле значения Coil отвергается
        } else {
            // Преобразуем 0xFF00 в 1 для Coil, либо оставляем 16-битное число как есть для регистра
            values[0] = fc == MB_FC_WRITE_COIL ? (uint16_t)(count == MB_COIL_ON) : count;
            // Вызываем обработчик записи карты для 1 элемента
            if (fc == MB_FC_WRITE_COIL && address == MB_STREAM_COIL) {
                m->stream_armed = (uint8_t)(!broadcast && values[0]);
            } else {
                error = m->write(m->context, fc == MB_FC_WRITE_COIL ? MB_COILS : MB_HOLDING, address, 1, values);
            }
            // При успешной записи ответ для функций 0x05 и 0x06 представляет собой полное эхо
            // запроса
            if (!error) {
                memcpy(r, q, 6); // Копируем все 6 байт запроса в буфер ответа
                n = 6; // Устанавливаем длину ответа равной 6 байтам
            }
        }
        break;
    }

    case MB_FC_WRITE_COILS: // 0x0F (15): Запись нескольких флагов Coils
    case MB_FC_WRITE_REGISTERS: { // 0x10 (16): Запись нескольких регистров Holding Registers
        // Запрос групповой записи должен содержать минимум 7 байт (заголовок + Byte Count)
        if (m->request_length < 7) {
            error = MB_ILLEGAL_VALUE; // Если кадр короче, возвращаем исключение
            break;
        }
        // Вычисляем ожидаемое число байтов данных исходя из заявленного количества элементов count
        bytes = fc == MB_FC_WRITE_COILS ? (count + 7u) / 8u : count * 2u;
        if (!count || count > MB_WRITE_MAX || q[6] != bytes || m->request_length != 7u + bytes ||
            // Проверяем лимиты количества, совпадение поля Byte Count (q[6]) с расчётным и общую
            // длину пакета
            (uint32_t)address + count > MB_ADDRESS_SPACE) {
            error = MB_ILLEGAL_VALUE; // При любом расхождении фиксируем ошибку структуры данных
        } else {
            for (i = 0; i < count; ++i) // Распаковываем входные данные во временный массив values
                // Для Coils извлекаем отдельные биты, для регистров — собираем 16-битные слова
                // Big-Endian
                values[i] = fc == MB_FC_WRITE_COILS ? (uint16_t)((q[7 + i / 8] >> (i % 8)) & 1) : be16(q + 7 + i * 2);
            // Передаём распакованный массив в транзакционный обработчик записи карты
            error = m->write(m->context, fc == MB_FC_WRITE_COILS ? MB_COILS : MB_HOLDING, address, count, values);
            // При успешной групповой записи ответ содержит первые 6 байт запроса (Адрес, FC,
            // начальный адрес и количество)
            if (!error) {
                memcpy(r, q, 6); // Копируем заголовок запроса в буфер ответа
                n = 6; // Длина ответа составляет 6 байт
            }
        }
        break;
    }

    default: // Если пришёл неподдерживаемый код функции Modbus
        error = MB_ILLEGAL_FUNCTION; // Выставляем стандартное исключение 0x01 (Illegal Function)
        break;
    }

    if (broadcast) return; // На широковещательные запросы ответ в линию никогда не отправляется
    if (error) { // Если при разборе или обращении к карте возникло исключение
        // Устанавливаем старший бит (0x80) в коде функции как признак ответа с ошибкой
        r[1] = (uint8_t)(fc | MB_EXCEPTION_FLAG);
        r[2] = (uint8_t)error; // Записываем код исключения Modbus во второй байт PDU
        n = 3; // Длина пакета исключения фиксирована и равна 3 байтам (Адрес, FC|0x80, Код ошибки)
        ++m->exceptions; // Увеличиваем диагностический счётчик сформированных исключений
    }
    if (!error && !replay && armed && fc >= 1 && fc <= 4) {
        memcpy(m->stream_request, q, 6);
        m->stream_active = 1;
    }
    if (error && replay) m->stream_active = 0;
    // Кодируем готовый двоичный ответ в формат Modbus ASCII с расчётом LRC
    m->response_length = (uint16_t)modbus_ascii_encode(r, n, m->response, sizeof(m->response));
}

// Сброс переменных состояния сборщика текущего принимаемого ASCII-кадра
static void reset_frame(modbus_ascii_t *m)
{
    m->request_length = 0; // Обнуляем длину накопленного двоичного запроса
    m->collecting = 0; // Снимаем флаг активного приёма кадра (ждём нового символа ':')
    m->half_byte = 0; // Сбрасываем признак ожидания второй половины байта (младшей тетрады)
    m->expect_lf = 0; // Сбрасываем флаг ожидания завершающего символа '\n' после получения '\r'
}

// Преобразование одиночного ASCII HEX-символа в числовое значение тетрады (0..15)
static int nibble(uint8_t ch)
{
    if (ch >= '0' && ch <= '9') return ch - '0'; // Для цифр '0'..'9' вычитаем код символа '0', получая 0..9
    if (ch >= 'A' && ch <= 'F') return ch - 'A' + 10; // Для заглавных букв 'A'..'F' получаем значения 10..15
    if (ch >= 'a' && ch <= 'f') return ch - 'a' + 10; // Допускаем также строчные буквы 'a'..'f' (10..15)
    return -1; // Любой другой символ не является шестнадцатеричной цифрой (возвращаем признак ошибки -1)
}

// Фоновый автомат разбора очереди приёма Modbus ASCII и отправки готового ответа (вызывается из
// главного цикла)
void modbus_ascii_poll(modbus_ascii_t *m, uint32_t ms, void *txctx, int (*send)(void *, const uint8_t *, size_t))
{
    // Ограничиваем максимальное число разбираемых символов за один вызов, чтобы не задерживать
    // главный цикл
    unsigned budget = MB_POLL_BUDGET;

    // Если из прерывания USB был запрошен сброс (переполнение буфера или отключение кабеля)
    if (m->reset_requested) {
        m->stream_active = m->stream_armed = m->response_is_stream = 0;
        m->reset_requested = 0; // Снимаем флаг запроса сброса
        m->tail = m->head; // Мгновенно опустошаем кольцевой буфер приёма, приравнивая хвост к голове
        reset_frame(m); // Сбрасываем состояние парсера текущего кадра
        m->response_length = 0; // Отменяем отправку непереданного ответа
    }

    // Если в буфере передачи лежит готовый ответ, который в прошлый раз не смог уйти из-за
    // занятости USB
    // Не задерживаем новую команду неотправленным повторным ответом.
    if (m->response_is_stream && m->tail != m->head) {
        m->response_length = 0;
        m->response_is_stream = 0;
    }
    if (m->response_length) {
        // Пытаемся снова передать ответ в USB; при успехе (код 0) очищаем длину ответа
        if (!send(txctx, m->response, m->response_length)) m->response_length = 0;
        return; // Пока текущий ответ не отправлен, новые входящие запросы не разбираем
    }

    // Кадр не закончен, очередь пуста, а новый USB-фрагмент не пришёл за допустимое время.
    if (m->collecting && m->tail == m->head && (uint32_t)(ms - m->last_rx_ms) >= MB_CHARACTER_TIMEOUT_MS) {
        reset_frame(m); // Отбрасываем недопринятый зависший кадр
        ++m->timeouts; // Увеличиваем счётчик ошибок таймаута кадра
    }

    // Пока не исчерпан лимит итераций за проход и в кольцевом буфере есть непрочитанные байты
    while (budget-- && m->tail != m->head) {
        unsigned slot = m->tail & (MB_RX_SIZE - 1u); // Вычисляем индекс читаемой ячейки кольцевого буфера
        uint8_t ch = m->ring[slot]; // Извлекаем очередной символ из буфера
        int digit; // Переменная для числового значения распознанной HEX-тетрады

        // Если перед этим символом в прерывании была зафиксирована длинная пауза, а мы собирали
        // кадр
        if (m->gap[slot] && m->collecting) {
            reset_frame(m); // Сбрасываем старый неоконченный кадр
            ++m->timeouts; // Фиксируем таймаут сборки
        }
        ++m->tail; // Продвигаем указатель чтения кольцевого буфера, освобождая ячейку для прерывания USB

        if (ch == ':') { // Если встретился стартовый символ нового кадра ':'
            reset_frame(m); // Очищаем любые остатки предыдущего кадра
            m->collecting = 1; // Включаем режим накопления данных кадра
            continue; // Переходим к чтению следующего символа из очереди
        }
        // Все символы до прихода стартового двоеточия ':' игнорируем как помеху на линии
        if (!m->collecting) continue;

        // Если предыдущим символом был возврат каретки '\r', сейчас мы обязаны получить '\n'
        if (m->expect_lf) {
            if (ch == '\n') { // Получен корректный завершающий символ перевода строки '\n'
                // Проверяем контрольную сумму LRC по всему принятому массиву (включая сам байт LRC
                // в конце); 0 означает совпадение
                if (!modbus_lrc(m->request, m->request_length)) {
                    // Уменьшаем длину на 1 байт, отрезая проверенный байт LRC от полезного PDU
                    --m->request_length;
                    execute(m, 0); // Запускаем выполнение команды Modbus и формирование ответа
                } else { // Если сумма LRC не сошлась
                    ++m->lrc_errors; // Увеличиваем диагностический счётчик ошибок контрольной суммы
                }
                reset_frame(m); // Очищаем состояние приёмника для следующего кадра
                // Если сформирован ответ, сразу пытаемся отправить его через callback USB
                if (m->response_length && !send(txctx, m->response, m->response_length))
                    // При успешной передаче в стек USB обнуляем длину ожидающего ответа
                    m->response_length = 0;
                // После обработки одного полного запроса выходим из функции, отдавая время другим
                // задачам главного цикла
                return;
            }
            // Если после '\r' пришёл любой символ кроме '\n' (и не ':', проверенный выше), кадр
            // повреждён — сбрасываем его
            reset_frame(m);
            continue; // Переходим к следующей итерации цикла
        }

        // Если пришёл символ '\r', при этом нет незакрытого полубайта и принято минимум 3 байта
        // (Адрес + FC + LRC)
        if (ch == '\r' && !m->half_byte && m->request_length >= 3) {
            m->expect_lf = 1; // Переводим автомат в состояние ожидания завершающего символа '\n'
            continue; // Читаем следующий символ
        }

        digit = nibble(ch); // Пытаемся декодировать текущий символ как шестнадцатеричную цифру (0..15)
        // Если пришёл недопустимый символ (или '\r' в нечётной позиции / слишком коротком кадре)
        if (digit < 0) {
            reset_frame(m); // Сбрасываем повреждённый кадр
            continue; // Продолжаем разбор очереди
        }

        if (!m->half_byte) { // Если это первый символ из пары (старшая тетрада байта)
            // Сдвигаем значение тетрады в старшие 4 бита и сохраняем во временном поле
            m->high_nibble = (uint8_t)(digit << 4);
            m->half_byte = 1; // Выставляем флаг ожидания младшей тетрады того же байта
        } else { // Если это второй символ из пары (младшая тетрада байта)
            if (m->request_length == MB_ADU_MAX) { // Проверяем, не переполнился ли буфер двоичного пакета
                ++m->overflows; // Фиксируем переполнение длины пакета
                reset_frame(m); // Отбрасываем слишком длинный кадр
                continue; // Переходим к следующему символу
            }
            // Объединяем старшую и младшую тетрады в целый байт и записываем в буфер запроса
            m->request[m->request_length++] = (uint8_t)(m->high_nibble | (unsigned)digit);
            m->half_byte = 0; // Сбрасываем флаг полубайта (готовы к приёму следующего байта или '\r')
        }
    }
}

// Вызывается после публикации нового измерительного кадра, не из IRQ.
void modbus_ascii_measurement(modbus_ascii_t *m)
{
    if (!m->stream_active || m->reset_requested) return;
    if (m->response_length || m->collecting || m->tail != m->head) {
        ++m->stream_dropped;
        return;
    }
    memcpy(m->request, m->stream_request, 6);
    m->request_length = 6;
    execute(m, 1);
    reset_frame(m);
    m->response_is_stream = 1;
}
